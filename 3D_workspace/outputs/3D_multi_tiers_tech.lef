MANUFACTURINGGRID 0.005 ;

LAYER metal1_logic_tier
    TYPE ROUTING ;
    PITCH 0.14 ;
    WIDTH 0.07 ;
    THICKNESS 0.13 ;
    SPACING 0.065  ;
    DIRECTION HORIZONTAL ;
    RESISTANCE RPERSQ 0.38 ;
    CAPACITANCE CPERSQDIST 7.7161e-05 ;
    EDGECAPACITANCE 2.7365e-05 ;
END metal1_logic_tier

LAYER via1_logic_tier
    TYPE CUT ;
    WIDTH 0.07 ;
    SPACING 0.08  ;
    RESISTANCE 5 ;
END via1_logic_tier

LAYER metal2_logic_tier
    TYPE ROUTING ;
    PITCH 0.19 ;
    WIDTH 0.07 ;
    THICKNESS 0.14 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 0.300 0.900 1.800 2.700 4.000
  WIDTH 0.000	 0.070 0.070 0.070 0.070 0.070 0.070
  WIDTH 0.090	 0.070 0.090 0.090 0.090 0.090 0.090
  WIDTH 0.270	 0.070 0.090 0.270 0.270 0.270 0.270
  WIDTH 0.500	 0.070 0.090 0.270 0.500 0.500 0.500
  WIDTH 0.900	 0.070 0.090 0.270 0.500 0.900 0.900
  WIDTH 1.500	 0.070 0.090 0.270 0.500 0.900 1.500 ;
    DIRECTION VERTICAL ;
    RESISTANCE RPERSQ 0.25 ;
    CAPACITANCE CPERSQDIST 4.0896e-05 ;
    EDGECAPACITANCE 2.5157e-05 ;
END metal2_logic_tier

LAYER via2_logic_tier
    TYPE CUT ;
    WIDTH 0.07 ;
    SPACING 0.09  ;
    RESISTANCE 5 ;
END via2_logic_tier

LAYER metal3_logic_tier
    TYPE ROUTING ;
    PITCH 0.14 ;
    WIDTH 0.07 ;
    THICKNESS 0.14 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 0.300 0.900 1.800 2.700 4.000
  WIDTH 0.000	 0.070 0.070 0.070 0.070 0.070 0.070
  WIDTH 0.090	 0.070 0.090 0.090 0.090 0.090 0.090
  WIDTH 0.270	 0.070 0.090 0.270 0.270 0.270 0.270
  WIDTH 0.500	 0.070 0.090 0.270 0.500 0.500 0.500
  WIDTH 0.900	 0.070 0.090 0.270 0.500 0.900 0.900
  WIDTH 1.500	 0.070 0.090 0.270 0.500 0.900 1.500 ;
    DIRECTION HORIZONTAL ;
    RESISTANCE RPERSQ 0.25 ;
    CAPACITANCE CPERSQDIST 2.7745e-05 ;
    EDGECAPACITANCE 2.5157e-05 ;
END metal3_logic_tier

LAYER via3_logic_tier
    TYPE CUT ;
    WIDTH 0.07 ;
    SPACING 0.09  ;
    RESISTANCE 5 ;
END via3_logic_tier

LAYER metal4_logic_tier
    TYPE ROUTING ;
    PITCH 0.28 ;
    WIDTH 0.14 ;
    THICKNESS 0.28 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 0.900 1.800 2.700 4.000
  WIDTH 0.000	 0.140 0.140 0.140 0.140 0.140
  WIDTH 0.270	 0.140 0.270 0.270 0.270 0.270
  WIDTH 0.500	 0.140 0.270 0.500 0.500 0.500
  WIDTH 0.900	 0.140 0.270 0.500 0.900 0.900
  WIDTH 1.500	 0.140 0.270 0.500 0.900 1.500 ;
    DIRECTION VERTICAL ;
    RESISTANCE RPERSQ 0.21 ;
    CAPACITANCE CPERSQDIST 2.0743e-05 ;
    EDGECAPACITANCE 3.0908e-05 ;
END metal4_logic_tier

LAYER via4_logic_tier
    TYPE CUT ;
    WIDTH 0.14 ;
    SPACING 0.16  ;
    RESISTANCE 3 ;
END via4_logic_tier

LAYER metal5_logic_tier
    TYPE ROUTING ;
    PITCH 0.28 ;
    WIDTH 0.14 ;
    THICKNESS 0.28 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 0.900 1.800 2.700 4.000
  WIDTH 0.000	 0.140 0.140 0.140 0.140 0.140
  WIDTH 0.270	 0.140 0.270 0.270 0.270 0.270
  WIDTH 0.500	 0.140 0.270 0.500 0.500 0.500
  WIDTH 0.900	 0.140 0.270 0.500 0.900 0.900
  WIDTH 1.500	 0.140 0.270 0.500 0.900 1.500 ;
    DIRECTION HORIZONTAL ;
    RESISTANCE RPERSQ 0.21 ;
    CAPACITANCE CPERSQDIST 1.3527e-05 ;
    EDGECAPACITANCE 2.3863e-06 ;
END metal5_logic_tier

LAYER via5_logic_tier
    TYPE CUT ;
    WIDTH 0.14 ;
    SPACING 0.16  ;
    RESISTANCE 3 ;
END via5_logic_tier

LAYER metal6_logic_tier
    TYPE ROUTING ;
    PITCH 0.28 ;
    WIDTH 0.14 ;
    THICKNESS 0.28 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 0.900 1.800 2.700 4.000
  WIDTH 0.000	 0.140 0.140 0.140 0.140 0.140
  WIDTH 0.270	 0.140 0.270 0.270 0.270 0.270
  WIDTH 0.500	 0.140 0.270 0.500 0.500 0.500
  WIDTH 0.900	 0.140 0.270 0.500 0.900 0.900
  WIDTH 1.500	 0.140 0.270 0.500 0.900 1.500 ;
    DIRECTION VERTICAL ;
    RESISTANCE RPERSQ 0.21 ;
    CAPACITANCE CPERSQDIST 1.0036e-05 ;
    EDGECAPACITANCE 2.3863e-05 ;
END metal6_logic_tier

LAYER via6_logic_tier
    TYPE CUT ;
    WIDTH 0.14 ;
    SPACING 0.16  ;
    RESISTANCE 3 ;
END via6_logic_tier

LAYER metal7_logic_tier
    TYPE ROUTING ;
    PITCH 0.8 ;
    WIDTH 0.4 ;
    THICKNESS 0.8 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 1.800 2.700 4.000
  WIDTH 0.000	 0.400 0.400 0.400 0.400
  WIDTH 0.500	 0.400 0.500 0.500 0.500
  WIDTH 0.900	 0.400 0.500 0.900 0.900
  WIDTH 1.500	 0.400 0.500 0.900 1.500 ;
    DIRECTION HORIZONTAL ;
    RESISTANCE RPERSQ 0.075 ;
    CAPACITANCE CPERSQDIST 7.9771e-06 ;
    EDGECAPACITANCE 3.2577e-05 ;
END metal7_logic_tier

LAYER via7_logic_tier
    TYPE CUT ;
    WIDTH 0.4 ;
    SPACING 0.44  ;
    RESISTANCE 1 ;
END via7_logic_tier

LAYER metal8_logic_tier
    TYPE ROUTING ;
    PITCH 0.8 ;
    WIDTH 0.4 ;
    THICKNESS 0.8 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 1.800 2.700 4.000
  WIDTH 0.000	 0.400 0.400 0.400 0.400
  WIDTH 0.500	 0.400 0.500 0.500 0.500
  WIDTH 0.900	 0.400 0.500 0.900 0.900
  WIDTH 1.500	 0.400 0.500 0.900 1.500 ;
    DIRECTION VERTICAL ;
    RESISTANCE RPERSQ 0.075 ;
    CAPACITANCE CPERSQDIST 5.0391e-06 ;
    EDGECAPACITANCE 2.3932e-05 ;
END metal8_logic_tier

LAYER via8_logic_tier
    TYPE CUT ;
    WIDTH 0.4 ;
    SPACING 0.44  ;
    RESISTANCE 1 ;
END via8_logic_tier

LAYER metal9_logic_tier
    TYPE ROUTING ;
    PITCH 1.6 ;
    WIDTH 0.8 ;
    THICKNESS 2 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 2.700 4.000
  WIDTH 0.000	 0.800 0.800 0.800
  WIDTH 0.900	 0.800 0.900 0.900
  WIDTH 1.500	 0.800 0.900 1.500 ;
    DIRECTION HORIZONTAL ;
    RESISTANCE RPERSQ 0.03 ;
    CAPACITANCE CPERSQDIST 3.6827e-06 ;
    EDGECAPACITANCE 3.0803e-05 ;
END metal9_logic_tier

LAYER via9_logic_tier
    TYPE CUT ;
    WIDTH 0.8 ;
    SPACING 0.88  ;
    RESISTANCE 0.5 ;
END via9_logic_tier

LAYER metal10_logic_tier
    TYPE ROUTING ;
    PITCH 1.6 ;
    WIDTH 0.8 ;
    THICKNESS 2 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 2.700 4.000
  WIDTH 0.000	 0.800 0.800 0.800
  WIDTH 0.900	 0.800 0.900 0.900
  WIDTH 1.500	 0.800 0.900 1.500 ;
    DIRECTION VERTICAL ;
    RESISTANCE RPERSQ 0.03 ;
    CAPACITANCE CPERSQDIST 2.2124e-06 ;
    EDGECAPACITANCE 2.3667e-05 ;
END metal10_logic_tier

LAYER TSV_L2
    TYPE CUT ;
    WIDTH 0.4 ;
    SPACING 0.44  ;
    RESISTANCE 1 ;
END TSV_L2

LAYER MB_L2
    TYPE CUT ;
    WIDTH 0.07 ;
    SPACING 0.09  ;
    RESISTANCE 5 ;
END MB_L2

LAYER metal5_cache_tier
    TYPE ROUTING ;
    PITCH 0.28 ;
    WIDTH 0.14 ;
    THICKNESS 0.28 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 0.900 1.800 2.700 4.000
  WIDTH 0.000	 0.140 0.140 0.140 0.140 0.140
  WIDTH 0.270	 0.140 0.270 0.270 0.270 0.270
  WIDTH 0.500	 0.140 0.270 0.500 0.500 0.500
  WIDTH 0.900	 0.140 0.270 0.500 0.900 0.900
  WIDTH 1.500	 0.140 0.270 0.500 0.900 1.500 ;
    DIRECTION HORIZONTAL ;
    RESISTANCE RPERSQ 0.21 ;
    CAPACITANCE CPERSQDIST 1.3527e-05 ;
    EDGECAPACITANCE 2.3863e-06 ;
END metal5_cache_tier

LAYER via4_cache_tier
    TYPE CUT ;
    WIDTH 0.14 ;
    SPACING 0.16  ;
    RESISTANCE 3 ;
END via4_cache_tier

LAYER metal4_cache_tier
    TYPE ROUTING ;
    PITCH 0.28 ;
    WIDTH 0.14 ;
    THICKNESS 0.28 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 0.900 1.800 2.700 4.000
  WIDTH 0.000	 0.140 0.140 0.140 0.140 0.140
  WIDTH 0.270	 0.140 0.270 0.270 0.270 0.270
  WIDTH 0.500	 0.140 0.270 0.500 0.500 0.500
  WIDTH 0.900	 0.140 0.270 0.500 0.900 0.900
  WIDTH 1.500	 0.140 0.270 0.500 0.900 1.500 ;
    DIRECTION VERTICAL ;
    RESISTANCE RPERSQ 0.21 ;
    CAPACITANCE CPERSQDIST 2.0743e-05 ;
    EDGECAPACITANCE 3.0908e-05 ;
END metal4_cache_tier

LAYER via3_cache_tier
    TYPE CUT ;
    WIDTH 0.07 ;
    SPACING 0.09  ;
    RESISTANCE 5 ;
END via3_cache_tier

LAYER metal3_cache_tier
    TYPE ROUTING ;
    PITCH 0.14 ;
    WIDTH 0.07 ;
    THICKNESS 0.14 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 0.300 0.900 1.800 2.700 4.000
  WIDTH 0.000	 0.070 0.070 0.070 0.070 0.070 0.070
  WIDTH 0.090	 0.070 0.090 0.090 0.090 0.090 0.090
  WIDTH 0.270	 0.070 0.090 0.270 0.270 0.270 0.270
  WIDTH 0.500	 0.070 0.090 0.270 0.500 0.500 0.500
  WIDTH 0.900	 0.070 0.090 0.270 0.500 0.900 0.900
  WIDTH 1.500	 0.070 0.090 0.270 0.500 0.900 1.500 ;
    DIRECTION HORIZONTAL ;
    RESISTANCE RPERSQ 0.25 ;
    CAPACITANCE CPERSQDIST 2.7745e-05 ;
    EDGECAPACITANCE 2.5157e-05 ;
END metal3_cache_tier

LAYER via2_cache_tier
    TYPE CUT ;
    WIDTH 0.07 ;
    SPACING 0.09  ;
    RESISTANCE 5 ;
END via2_cache_tier

LAYER metal2_cache_tier
    TYPE ROUTING ;
    PITCH 0.19 ;
    WIDTH 0.07 ;
    THICKNESS 0.14 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 0.300 0.900 1.800 2.700 4.000
  WIDTH 0.000	 0.070 0.070 0.070 0.070 0.070 0.070
  WIDTH 0.090	 0.070 0.090 0.090 0.090 0.090 0.090
  WIDTH 0.270	 0.070 0.090 0.270 0.270 0.270 0.270
  WIDTH 0.500	 0.070 0.090 0.270 0.500 0.500 0.500
  WIDTH 0.900	 0.070 0.090 0.270 0.500 0.900 0.900
  WIDTH 1.500	 0.070 0.090 0.270 0.500 0.900 1.500 ;
    DIRECTION VERTICAL ;
    RESISTANCE RPERSQ 0.25 ;
    CAPACITANCE CPERSQDIST 4.0896e-05 ;
    EDGECAPACITANCE 2.5157e-05 ;
END metal2_cache_tier

LAYER via1_cache_tier
    TYPE CUT ;
    WIDTH 0.07 ;
    SPACING 0.08  ;
    RESISTANCE 5 ;
END via1_cache_tier

LAYER metal1_cache_tier
    TYPE ROUTING ;
    PITCH 0.14 ;
    WIDTH 0.07 ;
    THICKNESS 0.13 ;
    SPACING 0.065  ;
    DIRECTION HORIZONTAL ;
    RESISTANCE RPERSQ 0.38 ;
    CAPACITANCE CPERSQDIST 7.7161e-05 ;
    EDGECAPACITANCE 2.7365e-05 ;
END metal1_cache_tier

LAYER TSV_C2M
    TYPE CUT ;
    WIDTH 0.4 ;
    SPACING 0.44  ;
    RESISTANCE 1 ;
END TSV_C2M

LAYER MB_C2M
    TYPE CUT ;
    WIDTH 0.07 ;
    SPACING 0.09  ;
    RESISTANCE 5 ;
END MB_C2M

LAYER metal1_memory_tier
    TYPE ROUTING ;
    PITCH 0.14 ;
    WIDTH 0.07 ;
    THICKNESS 0.13 ;
    SPACING 0.065  ;
    DIRECTION HORIZONTAL ;
    RESISTANCE RPERSQ 0.38 ;
    CAPACITANCE CPERSQDIST 7.7161e-05 ;
    EDGECAPACITANCE 2.7365e-05 ;
END metal1_memory_tier

LAYER via1_memory_tier
    TYPE CUT ;
    WIDTH 0.07 ;
    SPACING 0.08  ;
    RESISTANCE 5 ;
END via1_memory_tier

LAYER metal2_memory_tier
    TYPE ROUTING ;
    PITCH 0.19 ;
    WIDTH 0.07 ;
    THICKNESS 0.14 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 0.300 0.900 1.800 2.700 4.000
  WIDTH 0.000	 0.070 0.070 0.070 0.070 0.070 0.070
  WIDTH 0.090	 0.070 0.090 0.090 0.090 0.090 0.090
  WIDTH 0.270	 0.070 0.090 0.270 0.270 0.270 0.270
  WIDTH 0.500	 0.070 0.090 0.270 0.500 0.500 0.500
  WIDTH 0.900	 0.070 0.090 0.270 0.500 0.900 0.900
  WIDTH 1.500	 0.070 0.090 0.270 0.500 0.900 1.500 ;
    DIRECTION VERTICAL ;
    RESISTANCE RPERSQ 0.25 ;
    CAPACITANCE CPERSQDIST 4.0896e-05 ;
    EDGECAPACITANCE 2.5157e-05 ;
END metal2_memory_tier

LAYER via2_memory_tier
    TYPE CUT ;
    WIDTH 0.07 ;
    SPACING 0.09  ;
    RESISTANCE 5 ;
END via2_memory_tier

LAYER metal3_memory_tier
    TYPE ROUTING ;
    PITCH 0.14 ;
    WIDTH 0.07 ;
    THICKNESS 0.14 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 0.300 0.900 1.800 2.700 4.000
  WIDTH 0.000	 0.070 0.070 0.070 0.070 0.070 0.070
  WIDTH 0.090	 0.070 0.090 0.090 0.090 0.090 0.090
  WIDTH 0.270	 0.070 0.090 0.270 0.270 0.270 0.270
  WIDTH 0.500	 0.070 0.090 0.270 0.500 0.500 0.500
  WIDTH 0.900	 0.070 0.090 0.270 0.500 0.900 0.900
  WIDTH 1.500	 0.070 0.090 0.270 0.500 0.900 1.500 ;
    DIRECTION HORIZONTAL ;
    RESISTANCE RPERSQ 0.25 ;
    CAPACITANCE CPERSQDIST 2.7745e-05 ;
    EDGECAPACITANCE 2.5157e-05 ;
END metal3_memory_tier

LAYER via3_memory_tier
    TYPE CUT ;
    WIDTH 0.07 ;
    SPACING 0.09  ;
    RESISTANCE 5 ;
END via3_memory_tier

LAYER metal4_memory_tier
    TYPE ROUTING ;
    PITCH 0.28 ;
    WIDTH 0.14 ;
    THICKNESS 0.28 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 0.900 1.800 2.700 4.000
  WIDTH 0.000	 0.140 0.140 0.140 0.140 0.140
  WIDTH 0.270	 0.140 0.270 0.270 0.270 0.270
  WIDTH 0.500	 0.140 0.270 0.500 0.500 0.500
  WIDTH 0.900	 0.140 0.270 0.500 0.900 0.900
  WIDTH 1.500	 0.140 0.270 0.500 0.900 1.500 ;
    DIRECTION VERTICAL ;
    RESISTANCE RPERSQ 0.21 ;
    CAPACITANCE CPERSQDIST 2.0743e-05 ;
    EDGECAPACITANCE 3.0908e-05 ;
END metal4_memory_tier

LAYER via4_memory_tier
    TYPE CUT ;
    WIDTH 0.14 ;
    SPACING 0.16  ;
    RESISTANCE 3 ;
END via4_memory_tier

LAYER metal5_memory_tier
    TYPE ROUTING ;
    PITCH 0.28 ;
    WIDTH 0.14 ;
    THICKNESS 0.28 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 0.900 1.800 2.700 4.000
  WIDTH 0.000	 0.140 0.140 0.140 0.140 0.140
  WIDTH 0.270	 0.140 0.270 0.270 0.270 0.270
  WIDTH 0.500	 0.140 0.270 0.500 0.500 0.500
  WIDTH 0.900	 0.140 0.270 0.500 0.900 0.900
  WIDTH 1.500	 0.140 0.270 0.500 0.900 1.500 ;
    DIRECTION HORIZONTAL ;
    RESISTANCE RPERSQ 0.21 ;
    CAPACITANCE CPERSQDIST 1.3527e-05 ;
    EDGECAPACITANCE 2.3863e-06 ;
END metal5_memory_tier

LAYER via5_memory_tier
    TYPE CUT ;
    WIDTH 0.14 ;
    SPACING 0.16  ;
    RESISTANCE 3 ;
END via5_memory_tier

LAYER metal6_memory_tier
    TYPE ROUTING ;
    PITCH 0.28 ;
    WIDTH 0.14 ;
    THICKNESS 0.28 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 0.900 1.800 2.700 4.000
  WIDTH 0.000	 0.140 0.140 0.140 0.140 0.140
  WIDTH 0.270	 0.140 0.270 0.270 0.270 0.270
  WIDTH 0.500	 0.140 0.270 0.500 0.500 0.500
  WIDTH 0.900	 0.140 0.270 0.500 0.900 0.900
  WIDTH 1.500	 0.140 0.270 0.500 0.900 1.500 ;
    DIRECTION VERTICAL ;
    RESISTANCE RPERSQ 0.21 ;
    CAPACITANCE CPERSQDIST 1.0036e-05 ;
    EDGECAPACITANCE 2.3863e-05 ;
END metal6_memory_tier

LAYER via6_memory_tier
    TYPE CUT ;
    WIDTH 0.14 ;
    SPACING 0.16  ;
    RESISTANCE 3 ;
END via6_memory_tier

LAYER metal7_memory_tier
    TYPE ROUTING ;
    PITCH 0.8 ;
    WIDTH 0.4 ;
    THICKNESS 0.8 ;
SPACINGTABLE
  PARALLELRUNLENGTH 0.000 1.800 2.700 4.000
  WIDTH 0.000	 0.400 0.400 0.400 0.400
  WIDTH 0.500	 0.400 0.500 0.500 0.500
  WIDTH 0.900	 0.400 0.500 0.900 0.900
  WIDTH 1.500	 0.400 0.500 0.900 1.500 ;
    DIRECTION HORIZONTAL ;
    RESISTANCE RPERSQ 0.075 ;
    CAPACITANCE CPERSQDIST 7.9771e-06 ;
    EDGECAPACITANCE 3.2577e-05 ;
END metal7_memory_tier

VIA via1_4_logic_tier DEFAULT
    LAYER via1_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_logic_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal2_logic_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via1_4_logic_tier

VIA via1_0_logic_tier DEFAULT
    LAYER via1_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal2_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via1_0_logic_tier

VIA via1_1_logic_tier DEFAULT
    LAYER via1_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal2_logic_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via1_1_logic_tier

VIA via1_2_logic_tier DEFAULT
    LAYER via1_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal2_logic_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via1_2_logic_tier

VIA via1_3_logic_tier DEFAULT
    LAYER via1_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_logic_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal2_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via1_3_logic_tier

VIA via1_5_logic_tier DEFAULT
    LAYER via1_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_logic_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal2_logic_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via1_5_logic_tier

VIA via1_6_logic_tier DEFAULT
    LAYER via1_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_logic_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal2_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via1_6_logic_tier

VIA via1_7_logic_tier DEFAULT
    LAYER via1_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_logic_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal2_logic_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via1_7_logic_tier

VIA via1_8_logic_tier DEFAULT
    LAYER via1_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_logic_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal2_logic_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via1_8_logic_tier

VIA via2_8_logic_tier DEFAULT
    LAYER via2_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_logic_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal3_logic_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via2_8_logic_tier

VIA via2_4_logic_tier DEFAULT
    LAYER via2_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_logic_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal3_logic_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via2_4_logic_tier

VIA via2_5_logic_tier DEFAULT
    LAYER via2_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_logic_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal3_logic_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via2_5_logic_tier

VIA via2_7_logic_tier DEFAULT
    LAYER via2_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_logic_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal3_logic_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via2_7_logic_tier

VIA via2_6_logic_tier DEFAULT
    LAYER via2_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_logic_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal3_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via2_6_logic_tier

VIA via2_0_logic_tier DEFAULT
    LAYER via2_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal3_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via2_0_logic_tier

VIA via2_1_logic_tier DEFAULT
    LAYER via2_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal3_logic_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via2_1_logic_tier

VIA via2_2_logic_tier DEFAULT
    LAYER via2_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal3_logic_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via2_2_logic_tier

VIA via2_3_logic_tier DEFAULT
    LAYER via2_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_logic_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal3_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via2_3_logic_tier

VIA via3_2_logic_tier DEFAULT
    LAYER via3_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal3_logic_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal4_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via3_2_logic_tier

VIA via3_0_logic_tier DEFAULT
    LAYER via3_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal3_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal4_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via3_0_logic_tier

VIA via3_1_logic_tier DEFAULT
    LAYER via3_logic_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal3_logic_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal4_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via3_1_logic_tier

VIA via4_0_logic_tier DEFAULT
    LAYER via4_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal4_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal5_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via4_0_logic_tier

VIA via5_0_logic_tier DEFAULT
    LAYER via5_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal5_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal6_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via5_0_logic_tier

VIA via6_0_logic_tier DEFAULT
    LAYER via6_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal6_logic_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal7_logic_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
END via6_0_logic_tier

VIA via7_0_logic_tier DEFAULT
    LAYER via7_logic_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
    LAYER metal7_logic_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
    LAYER metal8_logic_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
END via7_0_logic_tier

VIA via8_0_logic_tier DEFAULT
    LAYER via8_logic_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
    LAYER metal8_logic_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
    LAYER metal9_logic_tier ;
      RECT  -0.4 -0.4 0.4 0.4 ;
END via8_0_logic_tier

VIA via9_0_logic_tier DEFAULT
    LAYER via9_logic_tier ;
      RECT  -0.4 -0.4 0.4 0.4 ;
    LAYER metal9_logic_tier ;
      RECT  -0.4 -0.4 0.4 0.4 ;
    LAYER metal10_logic_tier ;
      RECT  -0.4 -0.4 0.4 0.4 ;
END via9_0_logic_tier

VIARULE Via1Array-0_logic_tier GENERATE 
    LAYER metal1_logic_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER metal2_logic_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER via1_logic_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.15 BY 0.15 ;
END Via1Array-0_logic_tier

VIARULE Via1Array-1_logic_tier GENERATE 
    LAYER metal1_logic_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER metal2_logic_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER via1_logic_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.15 BY 0.15 ;
END Via1Array-1_logic_tier

VIARULE Via1Array-2_logic_tier GENERATE 
    LAYER metal1_logic_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER metal2_logic_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER via1_logic_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.15 BY 0.15 ;
END Via1Array-2_logic_tier

VIARULE Via1Array-3_logic_tier GENERATE 
    LAYER metal1_logic_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER metal2_logic_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER via1_logic_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.15 BY 0.15 ;
END Via1Array-3_logic_tier

VIARULE Via1Array-4_logic_tier GENERATE 
    LAYER metal1_logic_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER metal2_logic_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER via1_logic_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.15 BY 0.15 ;
END Via1Array-4_logic_tier

VIARULE Via2Array-0_logic_tier GENERATE 
    LAYER metal2_logic_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER metal3_logic_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER via2_logic_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via2Array-0_logic_tier

VIARULE Via2Array-1_logic_tier GENERATE 
    LAYER metal2_logic_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER metal3_logic_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER via2_logic_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via2Array-1_logic_tier

VIARULE Via2Array-2_logic_tier GENERATE 
    LAYER metal2_logic_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER metal3_logic_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER via2_logic_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via2Array-2_logic_tier

VIARULE Via2Array-3_logic_tier GENERATE 
    LAYER metal2_logic_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER metal3_logic_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER via2_logic_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via2Array-3_logic_tier

VIARULE Via2Array-4_logic_tier GENERATE 
    LAYER metal2_logic_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER metal3_logic_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER via2_logic_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via2Array-4_logic_tier

VIARULE Via3Array-0_logic_tier GENERATE 
    LAYER metal3_logic_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER metal4_logic_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER via3_logic_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via3Array-0_logic_tier

VIARULE Via3Array-1_logic_tier GENERATE 
    LAYER metal3_logic_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER metal4_logic_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER via3_logic_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via3Array-1_logic_tier

VIARULE Via3Array-2_logic_tier GENERATE 
    LAYER metal3_logic_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER metal4_logic_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER via3_logic_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via3Array-2_logic_tier

VIARULE Via4Array-0_logic_tier GENERATE 
    LAYER metal4_logic_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal5_logic_tier ;
      ENCLOSURE 0 0 ;
    LAYER via4_logic_tier ;
      RECT  -0.07 -0.07  0.07 0.07  ;
      SPACING 0.3 BY 0.3 ;
END Via4Array-0_logic_tier

VIARULE Via5Array-0_logic_tier GENERATE 
    LAYER metal5_logic_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal6_logic_tier ;
      ENCLOSURE 0 0 ;
    LAYER via5_logic_tier ;
      RECT  -0.07 -0.07  0.07 0.07  ;
      SPACING 0.3 BY 0.3 ;
END Via5Array-0_logic_tier

VIARULE Via6Array-0_logic_tier GENERATE 
    LAYER metal6_logic_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal7_logic_tier ;
      ENCLOSURE 0.13 0.13 ;
    LAYER via6_logic_tier ;
      RECT  -0.07 -0.07  0.07 0.07  ;
      SPACING 0.3 BY 0.3 ;
END Via6Array-0_logic_tier

VIARULE Via7Array-0_logic_tier GENERATE 
    LAYER metal7_logic_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal8_logic_tier ;
      ENCLOSURE 0 0 ;
    LAYER via7_logic_tier ;
      RECT  -0.2 -0.2  0.2 0.2  ;
      SPACING 0.84 BY 0.84 ;
END Via7Array-0_logic_tier

VIARULE Via8Array-0_logic_tier GENERATE 
    LAYER metal8_logic_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal9_logic_tier ;
      ENCLOSURE 0.2 0.2 ;
    LAYER via8_logic_tier ;
      RECT  -0.2 -0.2  0.2 0.2  ;
      SPACING 0.84 BY 0.84 ;
END Via8Array-0_logic_tier

VIARULE Via9Array-0_logic_tier GENERATE 
    LAYER metal10_logic_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal9_logic_tier ;
      ENCLOSURE 0 0 ;
    LAYER via9_logic_tier ;
      RECT  -0.4 -0.4  0.4 0.4  ;
      SPACING 1.68 BY 1.68 ;
END Via9Array-0_logic_tier

SPACING
  SAMENET metal1 metal1 0.065 ;
  SAMENET metal2 metal2 0.07 ;
  SAMENET metal3 metal3 0.07 ;
  SAMENET metal4 metal4 0.14 ;
  SAMENET metal5 metal5 0.14 ;
  SAMENET metal6 metal6 0.14 ;
  SAMENET metal7 metal7 0.4 ;
  SAMENET metal8 metal8 0.4 ;
  SAMENET metal9 metal9 0.8 ;
  SAMENET metal10 metal10 0.8 ;
  SAMENET via1 via1 0.08 ;
  SAMENET via2 via2 0.09 ;
  SAMENET via3 via3 0.09 ;
  SAMENET via4 via4 0.16 ;
  SAMENET via5 via5 0.16 ;
  SAMENET via6 via6 0.16 ;
  SAMENET via7 via7 0.44 ;
  SAMENET via8 via8 0.44 ;
  SAMENET via9 via9 0.88 ;
  SAMENET via1 via2 0 STACK ;
  SAMENET via2 via3 0 STACK ;
  SAMENET via3 via4 0 STACK ;
  SAMENET via4 via5 0 STACK ;
  SAMENET via5 via6 0 STACK ;
  SAMENET via6 via7 0 STACK ;
  SAMENET via7 via8 0 STACK ;
  SAMENET via8 via9 0 STACK ;

END SPACING

VIA via1_4_cache_tier DEFAULT
    LAYER via1_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_cache_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal2_cache_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via1_4_cache_tier

VIA via1_0_cache_tier DEFAULT
    LAYER via1_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal2_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via1_0_cache_tier

VIA via1_1_cache_tier DEFAULT
    LAYER via1_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal2_cache_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via1_1_cache_tier

VIA via1_2_cache_tier DEFAULT
    LAYER via1_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal2_cache_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via1_2_cache_tier

VIA via1_3_cache_tier DEFAULT
    LAYER via1_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_cache_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal2_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via1_3_cache_tier

VIA via1_5_cache_tier DEFAULT
    LAYER via1_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_cache_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal2_cache_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via1_5_cache_tier

VIA via1_6_cache_tier DEFAULT
    LAYER via1_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_cache_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal2_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via1_6_cache_tier

VIA via1_7_cache_tier DEFAULT
    LAYER via1_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_cache_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal2_cache_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via1_7_cache_tier

VIA via1_8_cache_tier DEFAULT
    LAYER via1_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_cache_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal2_cache_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via1_8_cache_tier

VIA via2_8_cache_tier DEFAULT
    LAYER via2_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_cache_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal3_cache_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via2_8_cache_tier

VIA via2_4_cache_tier DEFAULT
    LAYER via2_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_cache_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal3_cache_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via2_4_cache_tier

VIA via2_5_cache_tier DEFAULT
    LAYER via2_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_cache_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal3_cache_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via2_5_cache_tier

VIA via2_7_cache_tier DEFAULT
    LAYER via2_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_cache_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal3_cache_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via2_7_cache_tier

VIA via2_6_cache_tier DEFAULT
    LAYER via2_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_cache_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal3_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via2_6_cache_tier

VIA via2_0_cache_tier DEFAULT
    LAYER via2_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal3_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via2_0_cache_tier

VIA via2_1_cache_tier DEFAULT
    LAYER via2_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal3_cache_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via2_1_cache_tier

VIA via2_2_cache_tier DEFAULT
    LAYER via2_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal3_cache_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via2_2_cache_tier

VIA via2_3_cache_tier DEFAULT
    LAYER via2_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_cache_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal3_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via2_3_cache_tier

VIA via3_2_cache_tier DEFAULT
    LAYER via3_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal3_cache_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal4_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via3_2_cache_tier

VIA via3_0_cache_tier DEFAULT
    LAYER via3_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal3_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal4_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via3_0_cache_tier

VIA via3_1_cache_tier DEFAULT
    LAYER via3_cache_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal3_cache_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal4_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via3_1_cache_tier

VIA via4_0_cache_tier DEFAULT
    LAYER via4_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal4_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal5_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via4_0_cache_tier

VIA via5_0_cache_tier DEFAULT
    LAYER via5_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal5_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal6_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via5_0_cache_tier

VIA via6_0_cache_tier DEFAULT
    LAYER via6_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal6_cache_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal7_cache_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
END via6_0_cache_tier

VIA via7_0_cache_tier DEFAULT
    LAYER via7_cache_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
    LAYER metal7_cache_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
    LAYER metal8_cache_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
END via7_0_cache_tier

VIA via8_0_cache_tier DEFAULT
    LAYER via8_cache_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
    LAYER metal8_cache_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
    LAYER metal9_cache_tier ;
      RECT  -0.4 -0.4 0.4 0.4 ;
END via8_0_cache_tier

VIA via9_0_cache_tier DEFAULT
    LAYER via9_cache_tier ;
      RECT  -0.4 -0.4 0.4 0.4 ;
    LAYER metal9_cache_tier ;
      RECT  -0.4 -0.4 0.4 0.4 ;
    LAYER metal10_cache_tier ;
      RECT  -0.4 -0.4 0.4 0.4 ;
END via9_0_cache_tier

VIARULE Via1Array-0_cache_tier GENERATE 
    LAYER metal1_cache_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER metal2_cache_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER via1_cache_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.15 BY 0.15 ;
END Via1Array-0_cache_tier

VIARULE Via1Array-1_cache_tier GENERATE 
    LAYER metal1_cache_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER metal2_cache_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER via1_cache_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.15 BY 0.15 ;
END Via1Array-1_cache_tier

VIARULE Via1Array-2_cache_tier GENERATE 
    LAYER metal1_cache_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER metal2_cache_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER via1_cache_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.15 BY 0.15 ;
END Via1Array-2_cache_tier

VIARULE Via1Array-3_cache_tier GENERATE 
    LAYER metal1_cache_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER metal2_cache_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER via1_cache_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.15 BY 0.15 ;
END Via1Array-3_cache_tier

VIARULE Via1Array-4_cache_tier GENERATE 
    LAYER metal1_cache_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER metal2_cache_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER via1_cache_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.15 BY 0.15 ;
END Via1Array-4_cache_tier

VIARULE Via2Array-0_cache_tier GENERATE 
    LAYER metal2_cache_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER metal3_cache_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER via2_cache_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via2Array-0_cache_tier

VIARULE Via2Array-1_cache_tier GENERATE 
    LAYER metal2_cache_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER metal3_cache_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER via2_cache_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via2Array-1_cache_tier

VIARULE Via2Array-2_cache_tier GENERATE 
    LAYER metal2_cache_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER metal3_cache_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER via2_cache_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via2Array-2_cache_tier

VIARULE Via2Array-3_cache_tier GENERATE 
    LAYER metal2_cache_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER metal3_cache_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER via2_cache_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via2Array-3_cache_tier

VIARULE Via2Array-4_cache_tier GENERATE 
    LAYER metal2_cache_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER metal3_cache_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER via2_cache_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via2Array-4_cache_tier

VIARULE Via3Array-0_cache_tier GENERATE 
    LAYER metal3_cache_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER metal4_cache_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER via3_cache_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via3Array-0_cache_tier

VIARULE Via3Array-1_cache_tier GENERATE 
    LAYER metal3_cache_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER metal4_cache_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER via3_cache_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via3Array-1_cache_tier

VIARULE Via3Array-2_cache_tier GENERATE 
    LAYER metal3_cache_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER metal4_cache_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER via3_cache_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via3Array-2_cache_tier

VIARULE Via4Array-0_cache_tier GENERATE 
    LAYER metal4_cache_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal5_cache_tier ;
      ENCLOSURE 0 0 ;
    LAYER via4_cache_tier ;
      RECT  -0.07 -0.07  0.07 0.07  ;
      SPACING 0.3 BY 0.3 ;
END Via4Array-0_cache_tier

VIARULE Via5Array-0_cache_tier GENERATE 
    LAYER metal5_cache_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal6_cache_tier ;
      ENCLOSURE 0 0 ;
    LAYER via5_cache_tier ;
      RECT  -0.07 -0.07  0.07 0.07  ;
      SPACING 0.3 BY 0.3 ;
END Via5Array-0_cache_tier

VIARULE Via6Array-0_cache_tier GENERATE 
    LAYER metal6_cache_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal7_cache_tier ;
      ENCLOSURE 0.13 0.13 ;
    LAYER via6_cache_tier ;
      RECT  -0.07 -0.07  0.07 0.07  ;
      SPACING 0.3 BY 0.3 ;
END Via6Array-0_cache_tier

VIARULE Via7Array-0_cache_tier GENERATE 
    LAYER metal7_cache_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal8_cache_tier ;
      ENCLOSURE 0 0 ;
    LAYER via7_cache_tier ;
      RECT  -0.2 -0.2  0.2 0.2  ;
      SPACING 0.84 BY 0.84 ;
END Via7Array-0_cache_tier

VIARULE Via8Array-0_cache_tier GENERATE 
    LAYER metal8_cache_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal9_cache_tier ;
      ENCLOSURE 0.2 0.2 ;
    LAYER via8_cache_tier ;
      RECT  -0.2 -0.2  0.2 0.2  ;
      SPACING 0.84 BY 0.84 ;
END Via8Array-0_cache_tier

VIARULE Via9Array-0_cache_tier GENERATE 
    LAYER metal10_cache_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal9_cache_tier ;
      ENCLOSURE 0 0 ;
    LAYER via9_cache_tier ;
      RECT  -0.4 -0.4  0.4 0.4  ;
      SPACING 1.68 BY 1.68 ;
END Via9Array-0_cache_tier

SPACING
  SAMENET metal1 metal1 0.065 ;
  SAMENET metal2 metal2 0.07 ;
  SAMENET metal3 metal3 0.07 ;
  SAMENET metal4 metal4 0.14 ;
  SAMENET metal5 metal5 0.14 ;
  SAMENET metal6 metal6 0.14 ;
  SAMENET metal7 metal7 0.4 ;
  SAMENET metal8 metal8 0.4 ;
  SAMENET metal9 metal9 0.8 ;
  SAMENET metal10 metal10 0.8 ;
  SAMENET via1 via1 0.08 ;
  SAMENET via2 via2 0.09 ;
  SAMENET via3 via3 0.09 ;
  SAMENET via4 via4 0.16 ;
  SAMENET via5 via5 0.16 ;
  SAMENET via6 via6 0.16 ;
  SAMENET via7 via7 0.44 ;
  SAMENET via8 via8 0.44 ;
  SAMENET via9 via9 0.88 ;
  SAMENET via1 via2 0 STACK ;
  SAMENET via2 via3 0 STACK ;
  SAMENET via3 via4 0 STACK ;
  SAMENET via4 via5 0 STACK ;
  SAMENET via5 via6 0 STACK ;
  SAMENET via6 via7 0 STACK ;
  SAMENET via7 via8 0 STACK ;
  SAMENET via8 via9 0 STACK ;

END SPACING

VIA via1_4_memory_tier DEFAULT
    LAYER via1_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_memory_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal2_memory_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via1_4_memory_tier

VIA via1_0_memory_tier DEFAULT
    LAYER via1_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal2_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via1_0_memory_tier

VIA via1_1_memory_tier DEFAULT
    LAYER via1_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal2_memory_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via1_1_memory_tier

VIA via1_2_memory_tier DEFAULT
    LAYER via1_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal2_memory_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via1_2_memory_tier

VIA via1_3_memory_tier DEFAULT
    LAYER via1_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_memory_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal2_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via1_3_memory_tier

VIA via1_5_memory_tier DEFAULT
    LAYER via1_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_memory_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal2_memory_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via1_5_memory_tier

VIA via1_6_memory_tier DEFAULT
    LAYER via1_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_memory_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal2_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via1_6_memory_tier

VIA via1_7_memory_tier DEFAULT
    LAYER via1_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_memory_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal2_memory_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via1_7_memory_tier

VIA via1_8_memory_tier DEFAULT
    LAYER via1_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal1_memory_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal2_memory_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via1_8_memory_tier

VIA via2_8_memory_tier DEFAULT
    LAYER via2_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_memory_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal3_memory_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via2_8_memory_tier

VIA via2_4_memory_tier DEFAULT
    LAYER via2_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_memory_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal3_memory_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via2_4_memory_tier

VIA via2_5_memory_tier DEFAULT
    LAYER via2_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_memory_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal3_memory_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via2_5_memory_tier

VIA via2_7_memory_tier DEFAULT
    LAYER via2_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_memory_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal3_memory_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via2_7_memory_tier

VIA via2_6_memory_tier DEFAULT
    LAYER via2_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_memory_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal3_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via2_6_memory_tier

VIA via2_0_memory_tier DEFAULT
    LAYER via2_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal3_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via2_0_memory_tier

VIA via2_1_memory_tier DEFAULT
    LAYER via2_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal3_memory_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
END via2_1_memory_tier

VIA via2_2_memory_tier DEFAULT
    LAYER via2_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal3_memory_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
END via2_2_memory_tier

VIA via2_3_memory_tier DEFAULT
    LAYER via2_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal2_memory_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal3_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via2_3_memory_tier

VIA via3_2_memory_tier DEFAULT
    LAYER via3_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal3_memory_tier ;
      RECT  -0.07 -0.035 0.07 0.035 ;
    LAYER metal4_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via3_2_memory_tier

VIA via3_0_memory_tier DEFAULT
    LAYER via3_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal3_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal4_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via3_0_memory_tier

VIA via3_1_memory_tier DEFAULT
    LAYER via3_memory_tier ;
      RECT  -0.035 -0.035 0.035 0.035 ;
    LAYER metal3_memory_tier ;
      RECT  -0.035 -0.07 0.035 0.07 ;
    LAYER metal4_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via3_1_memory_tier

VIA via4_0_memory_tier DEFAULT
    LAYER via4_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal4_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal5_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via4_0_memory_tier

VIA via5_0_memory_tier DEFAULT
    LAYER via5_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal5_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal6_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
END via5_0_memory_tier

VIA via6_0_memory_tier DEFAULT
    LAYER via6_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal6_memory_tier ;
      RECT  -0.07 -0.07 0.07 0.07 ;
    LAYER metal7_memory_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
END via6_0_memory_tier

VIA via7_0_memory_tier DEFAULT
    LAYER via7_memory_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
    LAYER metal7_memory_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
    LAYER metal8_memory_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
END via7_0_memory_tier

VIA via8_0_memory_tier DEFAULT
    LAYER via8_memory_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
    LAYER metal8_memory_tier ;
      RECT  -0.2 -0.2 0.2 0.2 ;
    LAYER metal9_memory_tier ;
      RECT  -0.4 -0.4 0.4 0.4 ;
END via8_0_memory_tier

VIA via9_0_memory_tier DEFAULT
    LAYER via9_memory_tier ;
      RECT  -0.4 -0.4 0.4 0.4 ;
    LAYER metal9_memory_tier ;
      RECT  -0.4 -0.4 0.4 0.4 ;
    LAYER metal10_memory_tier ;
      RECT  -0.4 -0.4 0.4 0.4 ;
END via9_0_memory_tier

VIARULE Via1Array-0_memory_tier GENERATE 
    LAYER metal1_memory_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER metal2_memory_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER via1_memory_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.15 BY 0.15 ;
END Via1Array-0_memory_tier

VIARULE Via1Array-1_memory_tier GENERATE 
    LAYER metal1_memory_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER metal2_memory_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER via1_memory_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.15 BY 0.15 ;
END Via1Array-1_memory_tier

VIARULE Via1Array-2_memory_tier GENERATE 
    LAYER metal1_memory_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER metal2_memory_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER via1_memory_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.15 BY 0.15 ;
END Via1Array-2_memory_tier

VIARULE Via1Array-3_memory_tier GENERATE 
    LAYER metal1_memory_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER metal2_memory_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER via1_memory_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.15 BY 0.15 ;
END Via1Array-3_memory_tier

VIARULE Via1Array-4_memory_tier GENERATE 
    LAYER metal1_memory_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER metal2_memory_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER via1_memory_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.15 BY 0.15 ;
END Via1Array-4_memory_tier

VIARULE Via2Array-0_memory_tier GENERATE 
    LAYER metal2_memory_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER metal3_memory_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER via2_memory_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via2Array-0_memory_tier

VIARULE Via2Array-1_memory_tier GENERATE 
    LAYER metal2_memory_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER metal3_memory_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER via2_memory_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via2Array-1_memory_tier

VIARULE Via2Array-2_memory_tier GENERATE 
    LAYER metal2_memory_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER metal3_memory_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER via2_memory_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via2Array-2_memory_tier

VIARULE Via2Array-3_memory_tier GENERATE 
    LAYER metal2_memory_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER metal3_memory_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER via2_memory_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via2Array-3_memory_tier

VIARULE Via2Array-4_memory_tier GENERATE 
    LAYER metal2_memory_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER metal3_memory_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER via2_memory_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via2Array-4_memory_tier

VIARULE Via3Array-0_memory_tier GENERATE 
    LAYER metal3_memory_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER metal4_memory_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER via3_memory_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via3Array-0_memory_tier

VIARULE Via3Array-1_memory_tier GENERATE 
    LAYER metal3_memory_tier ;
      ENCLOSURE 0 0.035 ;
    LAYER metal4_memory_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER via3_memory_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via3Array-1_memory_tier

VIARULE Via3Array-2_memory_tier GENERATE 
    LAYER metal3_memory_tier ;
      ENCLOSURE 0.035 0 ;
    LAYER metal4_memory_tier ;
      ENCLOSURE 0.035 0.035 ;
    LAYER via3_memory_tier ;
      RECT  -0.035 -0.035  0.035 0.035  ;
      SPACING 0.16 BY 0.16 ;
END Via3Array-2_memory_tier

VIARULE Via4Array-0_memory_tier GENERATE 
    LAYER metal4_memory_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal5_memory_tier ;
      ENCLOSURE 0 0 ;
    LAYER via4_memory_tier ;
      RECT  -0.07 -0.07  0.07 0.07  ;
      SPACING 0.3 BY 0.3 ;
END Via4Array-0_memory_tier

VIARULE Via5Array-0_memory_tier GENERATE 
    LAYER metal5_memory_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal6_memory_tier ;
      ENCLOSURE 0 0 ;
    LAYER via5_memory_tier ;
      RECT  -0.07 -0.07  0.07 0.07  ;
      SPACING 0.3 BY 0.3 ;
END Via5Array-0_memory_tier

VIARULE Via6Array-0_memory_tier GENERATE 
    LAYER metal6_memory_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal7_memory_tier ;
      ENCLOSURE 0.13 0.13 ;
    LAYER via6_memory_tier ;
      RECT  -0.07 -0.07  0.07 0.07  ;
      SPACING 0.3 BY 0.3 ;
END Via6Array-0_memory_tier

VIARULE Via7Array-0_memory_tier GENERATE 
    LAYER metal7_memory_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal8_memory_tier ;
      ENCLOSURE 0 0 ;
    LAYER via7_memory_tier ;
      RECT  -0.2 -0.2  0.2 0.2  ;
      SPACING 0.84 BY 0.84 ;
END Via7Array-0_memory_tier

VIARULE Via8Array-0_memory_tier GENERATE 
    LAYER metal8_memory_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal9_memory_tier ;
      ENCLOSURE 0.2 0.2 ;
    LAYER via8_memory_tier ;
      RECT  -0.2 -0.2  0.2 0.2  ;
      SPACING 0.84 BY 0.84 ;
END Via8Array-0_memory_tier

VIARULE Via9Array-0_memory_tier GENERATE 
    LAYER metal10_memory_tier ;
      ENCLOSURE 0 0 ;
    LAYER metal9_memory_tier ;
      ENCLOSURE 0 0 ;
    LAYER via9_memory_tier ;
      RECT  -0.4 -0.4  0.4 0.4  ;
      SPACING 1.68 BY 1.68 ;
END Via9Array-0_memory_tier

SPACING
  SAMENET metal1 metal1 0.065 ;
  SAMENET metal2 metal2 0.07 ;
  SAMENET metal3 metal3 0.07 ;
  SAMENET metal4 metal4 0.14 ;
  SAMENET metal5 metal5 0.14 ;
  SAMENET metal6 metal6 0.14 ;
  SAMENET metal7 metal7 0.4 ;
  SAMENET metal8 metal8 0.4 ;
  SAMENET metal9 metal9 0.8 ;
  SAMENET metal10 metal10 0.8 ;
  SAMENET via1 via1 0.08 ;
  SAMENET via2 via2 0.09 ;
  SAMENET via3 via3 0.09 ;
  SAMENET via4 via4 0.16 ;
  SAMENET via5 via5 0.16 ;
  SAMENET via6 via6 0.16 ;
  SAMENET via7 via7 0.44 ;
  SAMENET via8 via8 0.44 ;
  SAMENET via9 via9 0.88 ;
  SAMENET via1 via2 0 STACK ;
  SAMENET via2 via3 0 STACK ;
  SAMENET via3 via4 0 STACK ;
  SAMENET via4 via5 0 STACK ;
  SAMENET via5 via6 0 STACK ;
  SAMENET via6 via7 0 STACK ;
  SAMENET via7 via8 0 STACK ;
  SAMENET via8 via9 0 STACK ;

END SPACING
END LIBRARY
